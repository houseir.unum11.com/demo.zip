Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView]
Time: 2026-10-04T12:43:26
Written by: IfcOpenShell 0.9.0alpha0-8c614fa
Made in: IfcOpenShell 0.9.0alpha0-8c614fa

# IfcBuildingStorey, L1
In: Building
Elevation: 0 mm

# IfcDistributionPort (2)
FlowDirection: SOURCEANDSINK

# IfcDistributionSystem, Cold water
PredefinedType: DOMESTICCOLDWATER

# IfcPipeSegment: Copper, P
In: L1
Type - PredefinedType: RIGIDSEGMENT
Group: Cold water
